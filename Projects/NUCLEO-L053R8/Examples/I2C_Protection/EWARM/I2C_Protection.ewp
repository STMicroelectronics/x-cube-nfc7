# IAR project I2C_Protection.ewp, settings and files
configuration I2C_Protection (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/st25dvxxkc; ../../../../../Drivers/BSP/NFC07A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../Binary/I2C_Protection.bin
  ILINK.IlinkOutputFile: I2C_Protection.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.c app_nfc7.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc_reg.c st25dvxxkc.c
  group Drivers/BSP/NFC07A1
    ../../../../../Drivers/BSP/NFC07A1/: nfc07a1.c nfc07a1_nfctag.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
