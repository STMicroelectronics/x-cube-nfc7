# Keil uVision project NDEF_URI.uvprojx, settings and files
target NDEF_URI (6190000::V6.19::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: NDEF_URI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ../NFC7/App;../NFC7/Target;../Core/Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/st25dvxxkc;../../../../../Drivers/BSP/NFC07A1;../../../../../Middlewares/ST/NDEF/Inc/message;../../../../../Middlewares/ST/NDEF/Inc/poller;../../../../../Middlewares/ST/NDEF/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Application/User/NFC7/App
    ../NFC7/App/: app_nfc7.c
  group Application/User/NFC7/Target
    ../NFC7/Target/: ndef_nfcv_wrapper.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc_reg.c st25dvxxkc.c
  group Drivers/BSP/NFC07A1
    ../../../../../Drivers/BSP/NFC07A1/: nfc07a1.c nfc07a1_nfctag.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Middlewares/MID_LIBRARY/Wireless/NDEF_LIB
    ../../../../../Middlewares/ST/NDEF/Src/message/: ndef_message.c ndef_record.c ndef_type_uri.c ndef_types.c ndef_type_empty.c
software components: CMSIS:CORE 5.6.0
